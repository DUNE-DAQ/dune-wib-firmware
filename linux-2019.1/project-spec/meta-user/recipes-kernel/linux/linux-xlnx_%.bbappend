SRC_URI_append = " file://macb-4.19.patch"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
